options:
  parameters:
    generate_options: qt_gui
    id: RTL_SDR_FM
    output_language: python
    title: RTL-SDR-FM
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2E6
  states: {}
- name: tune
  id: variable_qtgui_range
  parameters:
    start: '300'
    step: '.1'
    stop: '400'
    value: '315'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/hamburger/Desktop/SDR_detector/GRC_Companion/fob_output.bin
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '4'
    samp_rate: 2E6
    taps: firdes.low_pass(1.0, 2e6, 100e3, 50e3)
    type: ccc
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 20e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/8
    type: fir_filter_fff
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alias: low  pass out
    name: '"signal"'
    size: '1024'
    srate: samp_rate/8
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"bits"'
    size: '1024'
    srate: samp_rate/8
    type: float
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '60'
    freq0: tune*1e6
    gain0: '120'
    gain_mode0: 'False'
    if_gain0: '60'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', low_pass_filter_1, '0']
- [blocks_multiply_const_vxx_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_1, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_1, '0', qtgui_time_sink_x_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
