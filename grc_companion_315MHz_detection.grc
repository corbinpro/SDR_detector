options:
  parameters:
    generate_options: qt_gui
    id: RTL_SDR_FM
    output_language: python
    title: RTL-SDR-FM
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2.4E6
  states: {}
- name: tune
  id: variable_qtgui_range
  parameters:
    start: '308'
    step: '.1'
    stop: '318'
    value: '315'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: tune*1e6
    fftsize: '1024'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '60'
    freq0: tune*1e6
    gain0: '120'
    gain_mode0: 'False'
    if_gain0: '60'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
